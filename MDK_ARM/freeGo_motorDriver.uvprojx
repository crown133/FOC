# Keil uVision project freeGo_motorDriver.uvprojx, settings and files
target freeGo_motorDriver (6130001::V6.13.1::.\ARMCLANG)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: freeGo_motorDriver
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F405xx,ARM_MATH_CM4,__FPU_USED=1
  c include: ..\MDK_ARM;..\Config;..\delay;..\DRV;..\FastMath;..\FOC;..\PositionSensor;..\Hardware\Inc;..\Hardware\Drivers\STM32F4xx_HAL_Driver\Inc;..\Hardware\Drivers\CMSIS\Core;..\Hardware\Drivers\CMSIS\DSP\Include;..\Hardware\Drivers\CMSIS\DSP\Lib\ARMCLANG;..\..\freeGo_motorDriver-V1.2P;..\FlashWrite;..\Calibration;..\Hardware\Drivers\CMSIS\Include;..\Communication
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group SYS
    ../delay/: delay.c
    ../: main.c structs.h
    ./: startup_stm32f405xx.s
    ../Hardware/Drivers/CMSIS/Core/: core_cm4.h
    ../Hardware/Drivers/CMSIS/Include/: stm32f405xx.h
    ../Hardware/: stm32f4xx_hal_msp.c system_stm32f4xx.c stm32f4xx_it.c
  group Hardware
    ../Hardware/Src/: adc.c led.c spi.c sys.c tim.c can.c
  group Driver
    ../Hardware/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_usart.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash_ex.c
  group Math
    ../FastMath/: FastMath.c
    ../Hardware/Drivers/CMSIS/DSP/Lib/ARMCLANG/: arm_cortexM4lf_math.lib
    ../Hardware/Drivers/CMSIS/DSP/Include/: arm_math.h
  group DRV
    ../DRV/: DRV8323.c
  group FOC
    ../FOC/: foc.c
  group PositionSensor
    ../PositionSensor/: TLE5012B.c position.c
  group Config
    ../Config/: current_controller_config.h hw_config.h motor_config.h user_config.h
  group FLASH
    ../FlashWrite/: flash.c
  group Calibration
    ../Calibration/: calibration.c
  group Communication
    ../Communication/: CAN_com.c
